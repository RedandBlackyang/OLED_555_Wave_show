# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\CMSIS;..\User\LED;..\User\SysTick;..\User\USART;..\User\OLED;..\User\i2c;..\User\ADC;..\User\AdvancedTim;..\User\Key;..\Libraries\FWlib\inc;..\DSP_Libraries;..\User\pwm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FFT_LIBRARIES
    ../DSP_Libraries/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h fft_calculate.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/SysTick/: bsp_systick.c
    ../User/LED/: bsp_led.c
    ../User/USART/: bsp_usart.c
    ../User/OLED/: OLED_I2C.c
    ../User/ADC/: bsp_adc.c
    ../User/AdvancedTim/: bsp_advanced_timer.c
    ../User/Key/: bsp_key.c
    ../User/pwm/: bsp_pwm.c
  group DOC
    ../: README.md FFT.md
